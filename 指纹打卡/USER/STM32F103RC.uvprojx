# Keil uVision project STM32F103RC.uvprojx, settings and files
target STM32F103RC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RC +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\ADC;..\HARDWARE\KEY;..\STM32F10x_FWLib\inc;..\HARDWARE\TIMER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\GPIO;..\USER;..\HARDWARE\FP_Sensor;..\HARDWARE\UART_TFT;..\HARDWARE;..\HARDWARE\AS608;..\HARDWARE\MALLOC;..\HARDWARE\RTC;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\SDIO;..\HARDWARE\DS18B20;..\HARDWARE\EXTI;..\HARDWARE\OLED;..\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\1.44TFT;..\CORE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/UART_TFT/: uart_tft_bsp.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/1.44TFT/: GUI.c Lcd_Driver.c
    ../HARDWARE/GPIO/: gpio.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_exti.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/option/: cc936.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
